## board/rockchip/evb1_v10_rk3576/Kconfig
```kconfig
if TARGET_ROC_EVB1_V10_RK3576

config SYS_BOARD
	default "evb1_v10_rk3576"

config SYS_VENDOR
	default "rockchip"

endif
```
